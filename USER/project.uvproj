# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c include: ..\HAEDWARE\adc;..\HAEDWARE\exti;..\HAEDWARE\KEY;..\HAEDWARE\led;..\SYSTEM\delay;..\SYSTEM\sys;..\HAEDWARE\timer;..\HAEDWARE\display;..\HAEDWARE\reverse;..\HAEDWARE\buzzer;..\HAEDWARE\rtc;..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: STM32F10x.s main.c
  group Hardware
    ../HAEDWARE/adc/: adc.c
    ../HAEDWARE/exti/: exti.c
    ../HAEDWARE/KEY/: key.c
    ../HAEDWARE/led/: led.c
    ../HAEDWARE/timer/: timer.c
    ../HAEDWARE/display/: display.c
    ../HAEDWARE/buzzer/: buzzer.c
    ../HAEDWARE/reverse/: reverse.c
    ../HAEDWARE/rtc/: rtc.c
  group Sys
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
